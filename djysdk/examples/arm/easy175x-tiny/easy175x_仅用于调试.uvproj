# Keil uVision project easy175x_仅用于调试.uvproj, settings and files
target LPC1752 (ARM-GNU)
  device: LPC1752 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10003FFF) IROM(0-0x0FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: tiny-lpc1752.elf
  group src_bsp_arch_core
    ../../djysdk/djysrc/djyos/bsp/arch/arm/cortex_m/cortex_m3/core/: cpu.c cpus.S exception.c exceptions.S int_hard.c ints.S
  group src_bsp_arch_startup
    ../../djysdk/djysrc/djyos/bsp/arch/arm/cortex_m/cortex_m3/startup/lpc175x/: initcpuc.c
  group src_bsp_cpu_peripheral_src
    ../../djysdk/djysrc/djyos/bsp/cpu_peripheral/lpc175x/src/: cpu_peri.c gpio_17xx.c uart_lpc17xx_tiny.c
  group src_bsp_vendor_lib_CMSIS_CM3_CoreSupport
    ../../djysdk/djysrc/djyos/bsp/vendor_lib/CMSIS/CM3/CoreSupport/: core_cm3.c
  group src_djyos_buffer
    ../../djysdk/djysrc/djyos/djyos/buffer/: line.c ring.c
  group src_djyos_clock
    ../../djysdk/djysrc/djyos/djyos/clock/: clock.c
  group src_djyos_core
    ../../djysdk/djysrc/djyos/djyos/core/: djyos.c endian.c sys_init.c
  group src_djyos_djyfs
    ../../djysdk/djysrc/djyos/djyos/djyfs/: file.c
  group src_djyos_djyfs_fat
    ../../djysdk/djysrc/djyos/djyos/djyfs/fat/: djyFAT32.c
  group src_djyos_djyfs_flashfile
    ../../djysdk/djysrc/djyos/djyos/djyfs/flashfile/: ddr.c ecc256.c fdt.c flashfile.c mdr.c
  group src_djyos_driver
    ../../djysdk/djysrc/djyos/djyos/driver/: driver.c
  group src_djyos_easyIP
    ../../djysdk/djysrc/djyos/djyos/easyIP/: Ethernet.c Http.c Stack.c Timer.c app.c arp.c icmp.c ip.c tagexpand.c tcp.c udp.c web_server.c
  group src_djyos_gui_display
    ../../djysdk/djysrc/djyos/djyos/gui/display/: gk_display.c
  group src_djyos_gui_encoding
    ../../djysdk/djysrc/djyos/djyos/gui/encoding/: ascii.c encoding.c gb2312.c loc_string.c nls.c utf8.c
  group src_djyos_gui_font
    ../../djysdk/djysrc/djyos/djyos/gui/font/: ascii8x16.c ascii8x8.c font.c gb2312_16.c textshow.c
  group src_djyos_gui_gk_draw
    ../../djysdk/djysrc/djyos/djyos/gui/gk_draw/: gk_draw.c
  group src_djyos_gui_lib
    ../../djysdk/djysrc/djyos/djyos/gui/lib/: gk_api.c
  group src_djyos_gui_window
    ../../djysdk/djysrc/djyos/djyos/gui/window/: gk_clip.c gk_win.c
  group src_djyos_int
    ../../djysdk/djysrc/djyos/djyos/int/: int.c
  group src_djyos_lock
    ../../djysdk/djysrc/djyos/djyos/lock/: lock.c
  group src_djyos_memory
    ../../djysdk/djysrc/djyos/djyos/memory/: memb.c mems.c
  group src_djyos_msg
    ../../djysdk/djysrc/djyos/djyos/msg/: msg.c
  group src_djyos_pipe
    ../../djysdk/djysrc/djyos/djyos/pipe/: pipe.c
  group src_djyos_rsc
    ../../djysdk/djysrc/djyos/djyos/rsc/: rsc.c
  group src_djyos_shell
    ../../djysdk/djysrc/djyos/djyos/shell/: shell.c shell_fs.c
  group src_djyos_stdin
    ../../djysdk/djysrc/djyos/djyos/stdin/: stdin_dev.c
  group src_djyos_stdin_keypad
    ../../djysdk/djysrc/djyos/djyos/stdin/keypad/: key.c
  group src_djyos_stdin_touch
    ../../djysdk/djysrc/djyos/djyos/stdin/touch/: Touch.c
  group src_djyos_wdt
    ../../djysdk/djysrc/djyos/djyos/wdt/: wdt.c
  group src_loader_si
    ../../djysdk/djysrc/djyos/loader/si/: loader.c pre_loader.c
  group src_user_config
    ./src/user/config/: module_init.c
  group src_user_critical
    ./src/user/critical/: critical.c
  group src_user_src
    ./src/user/src/: main.c
